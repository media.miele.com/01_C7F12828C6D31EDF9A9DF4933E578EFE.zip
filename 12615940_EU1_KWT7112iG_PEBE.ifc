Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 0fc68406-a44c-45a1-915f-34181a9e53bf, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-26T09:07:58+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12615940_EU1_KWT7112iG_PEBE:36711204_EU1_12615940_KWT7112iG_PEBE, (2)
In: Default
Type - Material: z_Miele_Design_Glass Black, z_Miele_Design_Zinc_Steel, z_Miele_Design_PEBE, z_Miele_Design_Glass, z_Miele_Design_Steel_Chrom, z_Miele_Connection_Electric, Spruce, Polypropylene
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 595 mm; Height: 455 mm; Depth: 559 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 36711204_EU1_12615940_KWT7112iG_PEBE; sets with these values: 2
